# Keil uVision project SMonitor.uvprojx, settings and files
target SMonitor debug (6180000::V6.18::ARMCLANG)
  device: MIMXRT1011DAE5A NXP
  pack: NXP.MIMXRT1011_DFP.15.1.0
  cpu: CPUTYPE("Cortex-M7") FPU3(SFPU)
  output: sai_interrupt_record_playback.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MIMXRT1011DAE5A, SDK_I2C_BASED_COMPONENT_USED=1, BOARD_USE_CODEC=1, CODEC_WM8960_ENABLE, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../../devices/MIMXRT1011/drivers;../../../../../../components/codec/wm8960;../../../../../../components/codec;../../../../../../components/codec/port/wm8960;../../../../../../components/codec/port;../../../../../../components/codec/i2c;../../../../../../components/i2c;../../../../../../devices/MIMXRT1011/utilities/debug_console_lite;../../../../../../devices/MIMXRT1011;../../../../../../components/uart;../../../../../../components/lists;../../../../../../devices/MIMXRT1011/xip;../../../../xip;../../../../../../CMSIS/Core/Include
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1011xxxxx_ram.scf
  link misc: --remove --entry=Reset_Handler
  group source
    ./source/: sai_interrupt_record_playback.c music.h lpm.c lpm.h specific.c specific.h flexcom.c flexcom.h flexpwm.c flexpwm.h flexuart.c flexuart.h
  group board
    ./source/: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
    ../devices/MIMXRT1011/project_template/: peripherals.c peripherals.h
  group doc
    ./: readme.txt
  group drivers
    ../devices/MIMXRT1011/drivers/: fsl_lpi2c.c fsl_lpi2c.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.h fsl_clock.c fsl_sai.h fsl_sai.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_gpt.c fsl_gpt.h fsl_dcdc.c fsl_dcdc.h fsl_gpc.c fsl_gpc.h fsl_flexio.c fsl_flexio.h fsl_flexio_uart.c fsl_flexio_uart.h
  group codec
    ../components/codec/wm8960/: fsl_wm8960.h fsl_wm8960.c
    ../components/codec/: fsl_codec_common.h fsl_codec_common.c
    ../components/codec/i2c/: fsl_codec_i2c.h fsl_codec_i2c.c
  group codec/port/wm8960
    ../components/codec/port/wm8960/: fsl_codec_wm8960_adapter.c fsl_codec_wm8960_adapter.h
  group codec/port
    ../components/codec/port/: fsl_codec_adapter.h
  group component/i2c
    ../components/i2c/: fsl_adapter_i2c.h fsl_adapter_lpi2c.c
  group utilities
    ../devices/MIMXRT1011/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group device
    ../devices/MIMXRT1011/: fsl_device_registers.h MIMXRT1011.h MIMXRT1011_features.h system_MIMXRT1011.c system_MIMXRT1011.h
    ../devices/MIMXRT1011/drivers/: fsl_adc.c fsl_adc.h fsl_adc_etc.c fsl_adc_etc.h
  group component/uart
    ../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../devices/MIMXRT1011/arm/: startup_MIMXRT1011.S
  group xip
    ../devices/MIMXRT1011/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../boards/evkmimxrt1010/xip/: evkmimxrt1010_flexspi_nor_config.c evkmimxrt1010_flexspi_nor_config.h
  group CMSIS
    ../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h cachel1_armv7.h mpu_armv7.h
target SMonitor flexspi_nor_debug (6180000::V6.18::ARMCLANG)
  device: MIMXRT1011DAE5A NXP
  pack: NXP.MIMXRT1011_DFP.15.1.0
  cpu: CPUTYPE("Cortex-M7") FPU3(SFPU)
  output: SMonitor +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, PRINTF_ADVANCED_ENABLE=1,XIP_BOOT_HEADER_ENABLE=1, DEBUG, CPU_MIMXRT1011DAE5A, SDK_I2C_BASED_COMPONENT_USED=1, BOARD_USE_CODEC=1, CODEC_WM8960_ENABLE, MCUXPRESSO_SDK
  c misc: as above
  c include: ..;..\devices\MIMXRT1011\drivers;..\components\codec\wm8960;..\components\codec;..\components\codec\port\wm8960;..\components\codec\port;..\components\codec\i2c;..\components\i2c;..\devices\MIMXRT1011\utilities\debug_console_lite;..\devices\MIMXRT1011;..\components\uart;..\components\lists;..\devices\MIMXRT1011\xip;..\CMSIS\Core\Include;..\boards\evkmimxrt1010\xip;.\source;..\devices\MIMXRT1011\project_template
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1011xxxxx_flexspi_nor.scf
  link misc: --remove --entry=Reset_Handler --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
target SMonitor release (6180000::V6.18::ARMCLANG)
  device: MIMXRT1011DAE5A NXP
  pack: NXP.MIMXRT1011_DFP.15.1.0
  cpu: CPUTYPE("Cortex-M7") FPU3(SFPU)
  output: sai_interrupt_record_playback.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MIMXRT1011DAE5A, SDK_I2C_BASED_COMPONENT_USED=1, BOARD_USE_CODEC=1, CODEC_WM8960_ENABLE, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1011xxxxx_ram.scf
  link misc: --remove --entry=Reset_Handler
target SMonitor flexspi_nor_release (6180000::V6.18::ARMCLANG)
  device: MIMXRT1011DAE5A NXP
  pack: NXP.MIMXRT1011_DFP.15.1.0
  cpu: CPUTYPE("Cortex-M7") FPU3(SFPU)
  output: sai_interrupt_record_playback.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CPU_MIMXRT1011DAE5A, SDK_I2C_BASED_COMPONENT_USED=1, BOARD_USE_CODEC=1, CODEC_WM8960_ENABLE, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MIMXRT1011xxxxx_flexspi_nor.scf
  link misc: as above
